Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-05-31T13:28:54+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.10.18 - Exporter 23.0.10.18 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, Port_1610334
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_steel penthouse louvre bdxn intake LT_sacs:BDXNSO, NLRS_57_AIR_UN_steel penthouse louvre bdxn intake LT_sacs:BDXNSO:1610334
In: Default
Type - Description: Solid Air Penthouse louvre BDXN (air intake); Classification: 57.0 (Uniformat); Material: <Unnamed> (4), NLRS_57_sendzimir verzinkt_gen_sacs (14)
Type - Constraints - Default Elevation: 0 mm
Type - General - LookupTable: BDX
Type - Identity Data - Assembly Code: 57.0; Description: Solid Air Penthouse louvre BDXN (air intake); Manufacturer: Solid Air Climate Solutions; Model: BDXNSO; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 29-04-2021; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.18.01; NLRS_C_niveau ontwikkeling: LOD 400; Type Name: BDXNSO; URL: https://solid-air.nl/producten/buitenluchtroosters-en-dakkappen/dakkappen/bdxn-bdyn
Type - Model Properties - SACS_Option_1: RVS wire mesh
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_steel penthouse louvre bdxn intake LT_sacs; SACS_Base_Index: 2
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: BDXNSO; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 9.3506 m2; NLRS_C_hoogte: 700 mm; NLRS_M_c01_breedte: 800 mm; NLRS_M_c01_hoogte: 800 mm; SACS_Height: 700 mm; SACS_Length: 800 mm; SACS_Width: 800 mm; Size: 800x800; Volume: 0.0105662 m3
Identity Data - Mark: 5921; NLRS_C_description: Solid Air Penthouse louvre BDXN (air intake); NLRS_C_materiaal_kleur: no color treatment; NLRS_C_model: BDXNSO 800x800x700; SACS_Article_Code: NB; SACS_Gross_Cost: 2086; SACS_Price_Date: 14-01-2021
Materials and Finishes - SACS_Face_Color: NLRS_57_sendzimir verzinkt_gen_sacs; SACS_Material: Sendzimir galvanised steel; SACS_Material_Wire_mesh: 2x2 stainless steel
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 45; SACS_Max_Ploss: 50 Pa; System Classification: Supply Air
Mechanical - Flow - Flow: 0 m3/s; NLRS_M_c01_debiet: 0 m3/s; SACS_Lp_dBA: 0
Model Properties - SACS_Air_Velocity: 0 m/s; SACS_Color_Ral: no; SACS_Standard_Color: yes
Other - Family: NLRS_57_AIR_UN_steel penthouse louvre bdxn intake LT_sacs; Family and Type: NLRS_57_AIR_UN_steel penthouse louvre bdxn intake LT_sacs: BDXNSO; Type: BDXNSO; Type Id: 1605371
Phasing - Phase Created: New Construction
Visibility - SACS_Warning_Disabled: no
